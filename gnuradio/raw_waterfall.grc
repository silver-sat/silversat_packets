options:
  parameters:
    generate_options: qt_gui
    id: raw_waterfall
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: '437175000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: 16*8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500000-370
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: oversample*symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/(2*decimation)
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tom/Downloads/ss_pass_12_2_2025.cf32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: display
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: center_freq
    type: eng_float
    value: '437175000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/8
    fc: center_frequency
    fftsize: '8192'
    grid: 'True'
    gui_hint: 'display@0: 1, 0, 1,1'
    int_max: '-40'
    int_min: '-100'
    type: complex
    update_time: '0.1'
    wintype: window.WIN_HAMMING
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    comment: RF gain set to 0 for testing
    gain: '6'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

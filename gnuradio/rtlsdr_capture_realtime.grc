options:
  parameters:
    author: Tom Conrad
    description: This flowgraph uses the downlink frequency from Gpredict to adjust the received signal in real time.  It is stored to a WAV file I/Q data (stereo) as 32 bit floats using frequency updates from GPredict..
    generate_options: qt_gui
    id: rtlsdr_iq_capture_realtime
    output_language: python
    title: Silversat RTL-SDR Capture Script
  states: {}

blocks:
- name: chan_bw
  id: variable
  parameters:
    value: '45000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: doppler_freq
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tab0@0: 2, 0, 1, 1'
    label: 'Doppler Frequency:  '
    type: int
    value: '0'
  states: {}
- name: filter_transition_width
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: 16*8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: oversample*symbol_rate
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '16'
  states: {}
- name: signal_bw
  id: variable
  parameters:
    value: (1+0.5)*symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: symbol_sample_rate
  id: variable
  parameters:
    value: symbol_rate*samples_per_symbol
  states: {}
- name: transition
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    alias: tone_down
    amp: '1'
    freq: '-if_freq-(doppler_freq-freq)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: if_freq + chan_bw/2
    low_cutoff_freq: if_freq - chan_bw/2
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      This is the static frequency offset between
      both ends, if they were stationary.
      Note: 1ppm @ 437MHz = 437 Hz.
      And it could be off on both ends.
      Could also be initial calibration tolerance.
      Remember TCXO means stable  over temp, not accurate.
      Set this on test data with no doppler and leave it.
      For the satellite offset, 
      	it might be a matter of trial and error.
    freq: '0'
    sample_rate: symbol_sample_rate
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    alias: mix_down
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_32
    file: outfile
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate/decimation)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: center_freq
    type: eng_float
    value: '437175000'
  states: {}
- name: frequency_offset
  id: parameter
  parameters:
    label: frequency_offset
    type: eng_float
    value: '0'
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_freq
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: import_0_0_0_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: chan_bw/2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_bw/2
    decim: '1'
    gain: '1'
    samp_rate: symbol_sample_rate
    type: fir_filter_ccf
    width: filter_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Use this offset for fixed offset between sender and receiver
  states: {}
- name: outfile
  id: parameter
  parameters:
    comment: os.path.join(os.getenv('SILVERSAT_ROOT'), "captures/20260112_233622.557094.wav")
    type: str
    value: os.path.join(os.getenv('SILVERSAT_ROOT'), 'captures/', str(datetime.datetime.now().strftime("%Y%m%d_%H%M%S")) +'.wav')
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab0@0: 0, 0, 2, 1'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/decimation)
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab0@0: 0, 2, 2, 1'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/decimation)
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab0@0: 0, 1, 2, 1'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: 'True'
    center_freq: freq-if_freq
    comment: |-
      RF gain set to 0 for testing, 
      AGC should be OFF
    gain: '6'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    label0: '0'
    num_tabs: '1'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0_0, freq, gpredict_MsgPairToVar_0_0, inpair]
- [low_pass_filter_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

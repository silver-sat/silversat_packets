options:
  parameters:
    author: Tom Conrad
    description: This flowgraph uses the downlink frequency from Gpredict to adjust the received signal in real time.  It is stored to a WAV file I/Q data (stereo) as 32 bit floats.
    generate_options: qt_gui
    id: rtlsdr_iq_capture
    output_language: python
    title: Silversat RTL-SDR Capture Script
  states: {}

blocks:
- name: chan_bw
  id: variable
  parameters:
    value: '45000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: doppler_freq
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: 16*8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: oversample*symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: if_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    alias: tone_down
    amp: '1'
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: if_freq + chan_bw/2
    low_cutoff_freq: if_freq - chan_bw/2
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    alias: mix_down
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_32
    file: outfile
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate/decimation)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: center_freq
    type: eng_float
    value: '437175000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq-freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, chan_bw/2, transition, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: chan_bw/2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: output
    type: str
    value: '''~/silversat_packets/captures/'' + str(datetime.datetime.now().strftime("%Y%m%d_%H%M%S")) +''.wav'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/decimation)
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: 'True'
    center_freq: freq
    comment: |-
      RF gain set to 0 for testing, 
      AGC should be OFF
    gain: '6'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
